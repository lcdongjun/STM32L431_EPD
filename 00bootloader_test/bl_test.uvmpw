<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>E:\STM32L431\00bootloader_test\bl_test.uvmpw</WorkspaceName>

  <project>
    <PathAndName>.\bootloader\MDK-ARM\boot.uvprojx</PathAndName>
    <NodeIsActive>1</NodeIsActive>
  </project>

  <project>
    <PathAndName>.\user_app\MDK-ARM\user_app.uvprojx</PathAndName>
  </project>

</ProjectWorkspace>
