# Keil uVision project user_app.uvprojx, settings and files
target STM32L431 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L431CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: user_app +hex
  AfterMake: D:\mcu\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVERUSE_HAL_DRIVER,STM32L431xx,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_HAL_DRIVER,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/MALLOC;../HARDWARE/AHT20;../HARDWARE/DS3231;../HARDWARE/W25QXX;../HARDWARE/Button;../HARDWARE/ATcmd;../HARDWARE/TEST;../HARDWARE/4PIN2EPD;../HARDWARE/4PIN2EPD/Config;../HARDWARE/4PIN2EPD/Fonts;../HARDWARE/4PIN2EPD/Command;../HARDWARE/4PIN2EPD/GUI;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../HARDWARE/GBKFont;../Calendar
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../HARDWARE/TEST/: test.c
    ../Core/Src/: pwr_from.c SystemInfo.c delay.c sys.c main.c gpio.c freertos.c adc.c dma.c rtc.c spi.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c stm32l4xx_hal_timebase_tim.c
    ../Core/Inc/: SystemInfo.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Drivers/CMSIS/DSP/Include/: arm_math.h
    ../Core/Src/: system_stm32l4xx.c
  group HARDWARE
    ../HARDWARE/AHT20/: AHT20.c AHT20.h
    ../HARDWARE/W25QXX/: W25QXX.c W25QXX.h
    ../HARDWARE/Button/: Button.c Button.h
    ../HARDWARE/ATcmd/: ATcmd.c ATcmd.h
    ../HARDWARE/DS3231/: DS3231.c DS3231.h
  group MALLOC
    ../Drivers/MALLOC/: malloc.c malloc.h
  group 4PIN2EPD
    ../HARDWARE/4PIN2EPD/Config/: DEV_Config.c
    ../HARDWARE/4PIN2EPD/GUI/: GUI_Paint.c
    ../HARDWARE/4PIN2EPD/Fonts/: font16.c font24.c font48.c
    ../HARDWARE/4PIN2EPD/Command/: EPD_Command.c
    ../HARDWARE/GBKFont/: gbkfont.c gbkfont.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Calendar
    ../Calendar/: calendar.c calendar.h date.h
software components: CMSIS:CORE 6.1.0
